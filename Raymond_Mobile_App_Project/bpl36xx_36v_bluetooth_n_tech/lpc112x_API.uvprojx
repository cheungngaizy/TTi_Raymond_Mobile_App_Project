# Keil uVision project lpc112x_API.uvprojx, settings and files
target lpc112x_api (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1125JBD48/303 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lpc112x_API
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: .\hal\lpc_112x\cmsis_h;.\hal\lpc_112x\lpc112x_h;.\hal\lpc_112x\lpc_config_h;.\hal\lpc_112x\ring_buffer_h;.\hal\lpc_112x
  asm define: CORE_M0
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group lpc112x
    ./hal/lpc_112x/: lpc112x_api.h types.h
    ./hal/lpc_112x/startup/: keil_startup_lpc112x.s
    ./hal/lpc_112x/lpc_112x_api_c/: lpc112x_api_sys_clock.c lpc112x_api_adc.c lpc112x_api_gpio.c lpc112x_api_mrt.c lpc112x_api_pin_int.c lpc112x_api_sys_tick.c lpc112x_api_uart.c lpc112x_api_globle_int.c lpc112x_api_printf.c lpc112x_api_i2c.c
    ./hal/lpc_112x/lpc112x_c/: adc_112x.c chip_112x.c clock_112x.c gpio_112x.c i2c_112x.c i2cm_112x.c iap.c iocon_112x.c pmu_112x.c ssp_112x.c syscon_112x.c sysinit_112x.c timer_112x.c uart_112x.c wwdt_112x.c eeprom.c romdiv_112x.c rtc_ut.c
    ./hal/lpc_112x/ring_buffer_c/: ring_buffer.c
  group main
    ./: main.c
